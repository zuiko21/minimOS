/* bit scrambler for picoVDU   *
 * (27C64 pinout)              *
 * (c) 2024 Carlos Santisteban *
 * last modified 20240514-1840 */

/* *** compiler directives *** */
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

/* *** type definitions *** */
typedef	u_int8_t	byte;
typedef	u_int16_t	word;

/* *** global data *** */
/* data bits D0-D7 on chip are connected to VD2-4-6-7-5-3-1-0 */
byte	data[256] = {
	0x00, 0x80, 0x40, 0xC0, 0x01, 0x81, 0x41, 0xC1, 0x20, 0xA0, 0x60, 0xE0, 0x21, 0xA1, 0x61, 0xE1,
	0x02, 0x82, 0x42, 0xC2, 0x03, 0x83, 0x43, 0xC3, 0x22, 0xA2, 0x62, 0xE2, 0x23, 0xA3, 0x63, 0xE3,
	0x10, 0x90, 0x50, 0xD0, 0x11, 0x91, 0x51, 0xD1, 0x30, 0xB0, 0x70, 0xF0, 0x31, 0xB1, 0x71, 0xF1,
	0x12, 0x92, 0x52, 0xD2, 0x13, 0x93, 0x53, 0xD3, 0x32, 0xB2, 0x72, 0xF2, 0x33, 0xB3, 0x73, 0xF3,
	0x04, 0x84, 0x44, 0xC4, 0x05, 0x85, 0x45, 0xC5, 0x24, 0xA4, 0x64, 0xE4, 0x25, 0xA5, 0x65, 0xE5,
	0x06, 0x86, 0x46, 0xC6, 0x07, 0x87, 0x47, 0xC7, 0x26, 0xA6, 0x66, 0xE6, 0x27, 0xA7, 0x67, 0xE7,
	0x14, 0x94, 0x54, 0xD4, 0x15, 0x95, 0x55, 0xD5, 0x34, 0xB4, 0x74, 0xF4, 0x35, 0xB5, 0x75, 0xF5,
	0x16, 0x96, 0x56, 0xD6, 0x17, 0x97, 0x57, 0xD7, 0x36, 0xB6, 0x76, 0xF6, 0x37, 0xB7, 0x77, 0xF7,
	0x08, 0x88, 0x48, 0xC8, 0x09, 0x89, 0x49, 0xC1, 0x20, 0xA0, 0x60, 0xE0, 0x21, 0xA1, 0x61, 0xE1,
	0x0A, 0x8A, 0x4A, 0xCA, 0x0B, 0x8B, 0x4B, 0xC3, 0x22, 0xA2, 0x62, 0xE2, 0x23, 0xA3, 0x63, 0xE3,
	0x18, 0x98, 0x58, 0xD8, 0x19, 0x99, 0x59, 0xD1, 0x30, 0xB0, 0x70, 0xF0, 0x31, 0xB1, 0x71, 0xF1,
	0x1A, 0x9A, 0x5A, 0xDA, 0x1B, 0x9B, 0x5B, 0xD3, 0x32, 0xB2, 0x72, 0xF2, 0x33, 0xB3, 0x73, 0xF3,
	0x0C, 0x8C, 0x4C, 0xCC, 0x0D, 0x8D, 0x4D, 0xCD, 0x2C, 0xAC, 0x6C, 0xEC, 0x2D, 0xAD, 0x6D, 0xED,
	0x0E, 0x8E, 0x4E, 0xCE, 0x0F, 0x8F, 0x4F, 0xCF, 0x2E, 0xAE, 0x6E, 0xEE, 0x2F, 0xAF, 0x6F, 0xEF,
	0x1C, 0x9C, 0x5C, 0xDC, 0x1D, 0x9D, 0x5D, 0xDD, 0x3C, 0xBC, 0x7C, 0xFC, 0x3D, 0xBD, 0x7D, 0xFD,
	0x1E, 0x9E, 0x5E, 0xDE, 0x1F, 0x9F, 0x5F, 0xDF, 0x3E, 0xBE, 0x7E, 0xFE, 0x3F, 0xBF, 0x7F, 0xFF
};

/* address bits scrambling array */
word	a[16] = {
	0b0001000000000000, 0b0000000010000000, 0b0000000001000000, 0b0000000000100000,
	0b0000000000010000, 0b0000000000001000, 0b0000000000000100, 0b0000000000000010,
	0b0000000000000001, 0b0000000100000000, 0b0000001000000000, 0b0000100000000000,
	0b0000010000000000,				   0x0,				   0x0,				   0x0
};

/* *** function prototypes *** */
word	address(word ax);

/* *** main code *** */
int main(int argc, char* argv[]) {
	FILE*	f;		/* source and output file */
	char	s[80];	/* scrambled filename .shf */
	word	w;		/* file address */
	byte	d;		/* data read */
	byte	rom[8192];

	if ((f = fopen(argv[1], "rb")) == NULL) {	/* try opening source */
		printf("*** Can't open file! ***\n");
		return -1;
	}
	strcpy(s, argv[1]);							/* generate output filename */
	strcat(s, ".shf");
	printf("Scrambling %s into %s...\n", argv[1], s);

	w = 0;
	while (!feof(f)) {
		d = fgetc(f);							/* read data */
		rom[address(w++)]=data[d];				/* store in final form */
	}
	fclose(f);									/* reading is done */

	if ((f = fopen(s, "wb")) == NULL) {			/* try creating output */
		printf("*** Can't write result! ***\n");
		return -2;
	}
	fwrite(rom, 1, 8192, f);					/* write the whole scrambled array */
	fclose(f);									/* all done */
	printf("\t%d bytes OK!\n", w);

	return 0;
}

/* *** function definitions *** */
word	address(word ax) {
	word	final	= 0;
	word	mask	= 1;
	byte	bit;

	for (bit=0; bit<13; bit++) {
		if (ax & mask)		final |= a[bit];
		mask <<= 1;
	}

	return	final;
}
